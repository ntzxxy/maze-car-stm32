# Keil uVision project Maze_Car.uvprojx, settings and files
target Maze_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Maze_Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/Motor;../BSP/OLED;../BSP/KEY;../BSP/PID;../BSP/WIT;../BSP/VL6180X;..\BSP\Maze
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group MOTOR
    ../BSP/Motor/: motor.c motor.h pid.c pid.h
  group OLED
    ../BSP/OLED/: oled.c oled.h oledfont.h
  group KEY
    ../BSP/KEY/: key.c key.h app_key.c app_key.h
  group WIT
    ../BSP/WIT/: wit.c wit.h
  group PID
    ../BSP/PID/: pid_controller.c pid_controller.h pid_example.c pid_example.h
  group VL6180X
    ../BSP/VL6180X/: VL6180X.c VL6180X.h VL6180X_Reg.h Delay.c Delay.h
  group MAZE
    ../BSP/Maze/: maze.c maze.h
software components: CMSIS:CORE 4.3.0
